## boards/shields/jd16pad/Kconfig.defconfig
```kconfig
if SHIELD_JD16PAD

config ZMK_KEYBOARD_NAME
    default "Prototype JDU"

endif # SHIELD_JD16PAD
```
